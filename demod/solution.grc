options:
  parameters:
    generate_options: qt_gui
    id: solution
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: samp_rate // 12000
  states: {}
- name: lp_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '5000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: psk_const
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '[0xd3, 0x91]'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: byte
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-2'
    gate: 'True'
    ramp: '0'
    threshold: '-10'
    type: complex
  states: {state: bypassed}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: demod3.c32
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: demod.sigmf-data
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: psk_const
    fmax: '0.1'
    fmin: '-0.1'
    loop_bw: 2 * 3.14 / 100
  states: {}
- name: digital_correlate_access_code_tag_xx_1
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '"0101010101010101" + "".join(f"{b:08b}" for b in sync_word)'
    tagname: start
    threshold: '4'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_1_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '"0101010101010101" + "".join(f"{b:08b}" for b in sync_word)'
    tagname: start
    threshold: '4'
    type: byte
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '10'
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, tag='start'):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Message Printer',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[]
              )
              self.tag_name = tag
              self.reset()
              self.enabled = False

          def reset(self):
              self.current_byte = 0
              self.current_bits = 0

          def work(self, input_items, output_items):
              rel_offsets = set()
              for tag in self.get_tags_in_window(0, 0, len(input_items[0])):
                  if pmt.to_python(tag.key) == self.tag_name:
                      rel_offsets.add(tag.offset - self.nitems_read(0))
              for i, bit in enumerate(input_items[0]):
                  if i in rel_offsets:
                      self.enabled = True
                      self.reset()

                  self.current_byte = (self.current_byte << 1) | bit
                  self.current_bits += 1

                  if self.current_bits == 8:
                      c = chr(self.current_byte)
                      if self.enabled and (c.isprintable() or c == "\n"):
                          print(c, end="", flush=True)
                      self.reset()
                  
              return len(input_items[0])
    tag: '"start"'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, tag='start'):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Message Printer',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[]
              )
              self.tag_name = tag
              self.reset()
              self.enabled = False

          def reset(self):
              self.current_byte = 0
              self.current_bits = 0

          def work(self, input_items, output_items):
              rel_offsets = set()
              for tag in self.get_tags_in_window(0, 0, len(input_items[0])):
                  if pmt.to_python(tag.key) == self.tag_name:
                      rel_offsets.add(tag.offset - self.nitems_read(0))
              for i, bit in enumerate(input_items[0]):
                  if i in rel_offsets:
                      self.enabled = True
                      self.reset()

                  self.current_byte = (self.current_byte << 1) | bit
                  self.current_bits += 1

                  if self.current_bits == 8:
                      c = chr(self.current_byte)
                      if self.enabled and (c.isprintable() or c == "\n"):
                          print(c, end="", flush=True)
                      self.reset()
                  
              return len(input_items[0])
    tag: '"start"'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '300000'
    decim: decim
    samp_rate: samp_rate
    taps: lp_taps
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '500000'
    decim: decim
    samp_rate: samp_rate
    taps: lp_taps
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-140000'
    decim: decim
    samp_rate: samp_rate
    taps: lp_taps
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '100'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1.0'
    decim: '1'
    gain: '1'
    ntaps: 11*10
    samp_rate: samp_rate // decim
    sym_rate: '1200'
    type: fir_filter_ccf
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_xor_xx_0, '1']
- [analog_pwr_squelch_xx_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_file_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_xor_xx_0, '0', digital_correlate_access_code_tag_xx_1, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_xor_xx_0, '0']
- [digital_constellation_receiver_cb_0, '0', digital_correlate_access_code_tag_xx_1_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0, '1']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0, '2']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_0, '0']
- [digital_correlate_access_code_tag_xx_1, '0', epy_block_0, '0']
- [digital_correlate_access_code_tag_xx_1_0, '0', epy_block_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', analog_pwr_squelch_xx_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_file_sink_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
