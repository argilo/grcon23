options:
  parameters:
    generate_options: no_gui
    id: fsk
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: padding
  id: variable
  parameters:
    value: '50'
  states: {}
- name: secret_message
  id: variable
  parameters:
    value: '"Welcome back! This is Demod 101 part 2. flag{fr3quEnCy_sH1F7_k3y1nG}"'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '80'
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '[0xd3, 0x91]'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: demod.c32
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_repeat_1
  id: blocks_repeat
  parameters:
    interp: sps
    type: byte
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: offset * (2 * math.pi / samp_rate)
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '0.88'
    samp_rate: audio_rate
    sensitivity: 2 * math.pi
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: ([0] * padding) + ([0b01010101] * 4) + sync_word + [ord(c) for c in secret_message] + ([0] * padding)
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: ([0] * (8 * sps * (padding-1))) + ([1] * (8 * sps * (2 + 4 + len(sync_word) + len(secret_message)))) + ([0] * (8 * sps * (padding-1)))
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-deviation, +deviation]'
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: deviation * 2
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: ccc
    width: deviation / 2
    win: window.WIN_HAMMING
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: offset
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: samp_rate / audio_rate * 1.0010951597837716
    type: ccf
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: intx
    value: '960000'
  states: {}

connections:
- [blocks_multiply_xx_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_repeat_1, '0']
- [blocks_repeat_1, '0', digital_chunks_to_symbols_xx_1, '0']
- [blocks_rotator_cc_0, '0', blocks_file_sink_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0, '1']
- [blocks_vector_source_x_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_vector_source_x_1, '0', blocks_multiply_xx_0, '0']
- [digital_chunks_to_symbols_xx_1, '0', blocks_vco_c_0, '0']
- [filter_fft_low_pass_filter_0, '0', pfb_arb_resampler_xxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_rotator_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
