options:
  parameters:
    generate_options: no_gui
    id: ask
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: padding
  id: variable
  parameters:
    value: '50'
  states: {}
- name: secret_message
  id: variable
  parameters:
    value: '"Well hello there! This is Demod 101 part 1. flag{0n_ofF_k3y1nG}"'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '60'
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '[0xd3, 0x91]'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: demod.c32
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_repeat_1
  id: blocks_repeat
  parameters:
    interp: sps
    type: byte
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: offset * (2 * math.pi / samp_rate)
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: ([0] * padding) + ([0b01010101] * 4) + sync_word + [ord(c) for c in secret_message] + ([0] * padding)
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[0, 1]'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: offset
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: samp_rate / audio_rate * 0.9987905271665417
    type: ccf
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '10.0'
    decim: '1'
    gain: '0.9'
    ntaps: 11*sps
    samp_rate: audio_rate
    sym_rate: audio_rate / sps
    type: fir_filter_ccf
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: intx
    value: '960000'
  states: {}

connections:
- [blocks_float_to_complex_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_repeat_1, '0']
- [blocks_repeat_1, '0', digital_chunks_to_symbols_xx_1, '0']
- [blocks_rotator_cc_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [digital_chunks_to_symbols_xx_1, '0', blocks_float_to_complex_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_rotator_cc_0, '0']
- [root_raised_cosine_filter_0, '0', pfb_arb_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
